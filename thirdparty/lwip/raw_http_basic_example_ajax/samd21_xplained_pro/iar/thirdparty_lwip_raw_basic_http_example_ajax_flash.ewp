# IAR project thirdparty_lwip_raw_basic_http_example_ajax_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; TC_ASYNC=true; EXTINT_CALLBACK_MODE=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../sam0/utils/cmsis/samd21/source; ../../../../../sam0/utils/cmsis/samd21/include; ../../../../../sam0/drivers/port; ../../../lwip-1.4.1/src/include/ipv4; ../../../../../sam0/drivers/system/reset; ../../../../../sam0/drivers/extint/extint_sam_d_r_h; ..; ../../../../../sam0/utils/preprocessor; ../../../../../common2/services/delay; ../../../../../sam0/drivers/sercom/spi; ../../../lwip-1.4.1/src/include; ../../../../../sam0/utils; ../../../../../sam0/drivers/sercom; ../../../../../sam0/drivers/system/power; ../../../../../sam0/boards; ../../../lwip-port-1.4.1/sam/include/netif; ../../../../../sam0/drivers/sercom/usart; ../../../../../common/services/serial; ../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../lwip-1.4.1/src/include/lwip; ../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../sam0/drivers/system/interrupt; ../../network; ../../../../../sam0/drivers/tc; ../../network/httpserver; ../../../../../common2/services/delay/sam0; ../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../sam0/drivers/system/pinmux; ../..; ../../../../../common/boards; ../../../../../sam0/components/ethernet_phy/ksz8851snl; ../../../../../sam0/drivers/system; ../../../lwip-port-1.4.1/sam/include; ../../../../../sam0/drivers/extint; ../../../../../sam0/utils/header_files; ../../../../../sam0/boards/samd21_xplained_pro; ../../../../../sam0/utils/stdio/stdio_serial; ../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_lwip_raw_basic_http_example_ajax_flash.bin
  ILINK.IlinkOutputFile: thirdparty_lwip_raw_basic_http_example_ajax_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0; --config_def __ICFEDIT_size_cstack__=0xa00
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../lwip-1.4.1/src/api/: sockets.c api_lib.c netbuf.c api_msg.c tcpip.c err.c netifapi.c netdb.c
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../lwip-1.4.1/src/core/: tcp_in.c mem.c stats.c dhcp.c lwip_init.c tcp_out.c dns.c sys.c raw.c pbuf.c def.c netif.c udp.c tcp.c lwip_timers_141.c memp.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../lwip-1.4.1/src/core/ipv4/: inet_chksum.c icmp.c igmp.c ip_frag.c autoip.c inet.c ip_addr.c ip.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../lwip-1.4.1/src/include/lwip/: def.h raw.h opt.h snmp_msg.h err.h netdb.h snmp.h netifapi.h init.h netbuf.h sockets.h netif.h api.h timers.h tcp.h udp.h tcpip.h api_msg.h debug.h pbuf.h sio.h memp.h mem.h arch.h snmp_asn1.h snmp_structs.h sys.h dns.h dhcp.h memp_std.h stats.h tcp_impl.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../lwip-1.4.1/src/include/ipv4/lwip/: ip_frag.h inet.h ip.h inet_chksum.h igmp.h autoip.h ip_addr.h icmp.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../lwip-1.4.1/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/raw_http_basic_example_ajax
    ../../: main.c
  group thirdparty/lwip/raw_http_basic_example_ajax/network
    ../../network/: ethernet.c timer_mgt.c ethernet.h timer_mgt.h
  group thirdparty/lwip/raw_http_basic_example_ajax/network/httpserver
    ../../network/httpserver/: fsdata.c httpd.c fs.c fsdata.h httpd.h fs.h
  group thirdparty/lwip/raw_http_basic_example_ajax/samd21_xplained_pro
    ../: conf_timer.h conf_board.h conf_eth.h lwipopts.h conf_spi.h conf_clocks.h conf_extint.h
  group thirdparty/lwip/raw_http_basic_example_ajax/samd21_xplained_pro/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../lwip-port-1.4.1/sam/netif/: sam0_spi_ksz8851snl.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../lwip-port-1.4.1/sam/include/netif/: sam0_spi_ksz8851snl.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group sam0/utils
    ../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/stdio
    ../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../sam0/utils/cmsis/samd21/include/: samd21e16l.h samd21e15bu.h samd21e16a.h samd21j15a.h samd21e18a.h samd21e16bu.h samd21g16a.h samd21e17a.h samd21g16b.h samd21e15a.h samd21g15l.h samd21e15b.h samd21j16b.h samd21g18au.h samd21g18a.h samd21e15l.h samd21j18a.h samd21.h samd21g15b.h samd21j16a.h samd21j15b.h samd21g16l.h samd21g17a.h samd21g17au.h samd21g15a.h samd21e16b.h samd21j17a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../sam0/utils/cmsis/samd21/include/instance/: tc4.h mtb.h sercom4.h nvmctrl.h tcc1.h tc6.h evsys.h sercom0.h gclk.h sercom3.h ac1.h port.h i2s.h wdt.h sercom2.h sercom5.h sysctrl.h dmac.h tcc0.h pac1.h pac2.h eic.h sercom1.h dsu.h sbmatrix.h pac0.h ac.h pm.h tc7.h tcc2.h adc.h usb.h tc3.h rtc.h tc5.h dac.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21e15b.h samd21e15bu.h samd21e17a.h samd21g15a.h samd21g17a.h samd21g16b.h samd21j18a.h samd21g17au.h samd21e15l.h samd21e16bu.h samd21g15l.h samd21g16l.h samd21g18au.h samd21j15a.h samd21j17a.h samd21j15b.h samd21e18a.h samd21g16a.h samd21g15b.h samd21e15a.h samd21e16l.h samd21g18a.h samd21j16b.h samd21e16b.h samd21j16a.h samd21e16a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../sam0/utils/cmsis/samd21/include/component/: pm.h usb.h evsys.h gclk.h pac.h wdt.h eic.h dac.h tcc_lighting.h ac.h tc.h dsu.h mtb.h tcc.h sercom.h sysctrl.h nvmctrl.h hmatrixb.h i2s.h adc.h rtc.h dmac.h port.h
  group sam0/utils/preprocessor
    ../../../../../sam0/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h mrecursion.h stringz.h
  group sam0/utils/header_files
    ../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/tc
    ../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/sercom
    ../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom.h sercom_interrupt.h sercom_pinout.h
  group sam0/drivers/sercom/spi
    ../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/usart
    ../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/port
    ../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/extint
    ../../../../../sam0/drivers/extint/: extint_callback.c extint_callback.h extint.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/components/ethernet_phy/ksz8851snl
    ../../../../../sam0/components/ethernet_phy/ksz8851snl/: ksz8851snl.c ksz8851snl.h ksz8851snl_reg.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common/services/serial
    ../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
