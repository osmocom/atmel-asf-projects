# IAR project samd_qtouch_selfcap_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; RTC_COUNT_ASYNC=true; BOARD=SAMD21_XPLAINED_PRO; TC_ASYNC=true; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; _QTOUCH_; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../../../qdebug; ../../../../../../../../../common2/services/delay; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../../common/services/serial; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../../../common/utils; ../../qtouch; ../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../include; ../../../../../../../../../sam0/drivers/tc; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../common; ..; ../../../../../../../../../common2/services/delay/sam0; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../../../../../common/boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../..; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../..; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: samd_qtouch_selfcap_example_flash.bin
  ILINK.IlinkOutputFile: samd_qtouch_selfcap_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam0/samd/lib/iar
    ../../../../lib/iar/: libsamd21_qt_iar.a
  group thirdparty/qtouch/devspecific/sam0/samd/common
    ../../../../common/: BitBangSPI_Master.c BitBangSPI_Master.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_selfcap
    ../../: main.c
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_selfcap/qtouch
    ../../qtouch/: touch.c QDebugSettings.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_selfcap/samd21_xplained_pro
    ../: conf_board.h touch_config_samd.h conf_clocks.h
  group thirdparty/qtouch/devspecific/sam0/samd/examples/example_selfcap/samd21_xplained_pro/iar
    ./: asf.h
  group thirdparty/qtouch/devspecific/sam0/samd/include
    ../../../../include/: touch_api_SAMD.h
  group thirdparty/qtouch/qdebug
    ../../../../../../../qdebug/: QDebugTransport.c QDebug_samd.c QDebugTransport.h QDebug_samd.h
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_count_interrupt.h rtc_count.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count.c rtc_count_interrupt.c
  group sam0/drivers/tc
    ../../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21g18au.h samd21e16bu.h samd21g16a.h samd21g15l.h samd21.h samd21j16a.h samd21j15b.h samd21g18a.h samd21g17a.h samd21g15b.h samd21e17a.h samd21e15b.h samd21e16a.h samd21g15a.h samd21j16b.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e16b.h samd21e15a.h samd21g17au.h samd21g16b.h samd21g16l.h samd21e16l.h samd21e15bu.h samd21e15l.h samd21j15a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g16l.h samd21e15l.h samd21e15a.h samd21e15b.h samd21e16l.h samd21g15a.h samd21j15a.h samd21e17a.h samd21j17a.h samd21e16b.h samd21g15l.h samd21g15b.h samd21g16b.h samd21g16a.h samd21j16a.h samd21g18a.h samd21g17au.h samd21j16b.h samd21e18a.h samd21g17a.h samd21e16a.h samd21j18a.h samd21e16bu.h samd21j15b.h samd21g18au.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h mtb.h i2s.h tcc.h pm.h tc.h wdt.h gclk.h pac.h rtc.h sysctrl.h usb.h dac.h dsu.h sercom.h ac.h eic.h tcc_lighting.h nvmctrl.h hmatrixb.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h sercom3.h pac0.h pac2.h tc7.h mtb.h tc5.h adc.h dsu.h tc3.h eic.h tcc2.h port.h sercom1.h tcc0.h tcc1.h sercom2.h sbmatrix.h i2s.h sercom4.h dac.h nvmctrl.h gclk.h ac1.h wdt.h sercom0.h pac1.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h usb.h pm.h rtc.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
