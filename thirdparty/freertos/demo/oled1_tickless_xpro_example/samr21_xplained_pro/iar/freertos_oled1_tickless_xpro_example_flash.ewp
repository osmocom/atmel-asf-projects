# IAR project freertos_oled1_tickless_xpro_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMR21_XPLAINED_PRO; TC_ASYNC=true; GFX_MONO_LCD_HEIGHT=64; __SAMR21G18A__; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; __FREERTOS__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/reset; ../../../../../../common2/services/gfx_mono; ../../../../../../sam0/utils/preprocessor; ../../../../../../sam0/utils/cmsis/samr21/source; ../../../../../../common2/services/delay; ../../../../../../sam0/drivers/sercom/spi; ..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/sercom/usart; ../..; ../../../../../../common2/components/display/ssd1306; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt; ../../../../../../sam0/drivers/tc; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../freertos-8.0.1/Source/include; ../../../../../../common2/services/delay/sam0; ../../../../freertos-8.0.1/Source/portable/IAR/ARM_CM0; ../../../../../../sam0/boards/samr21_xplained_pro; ../../../../../../sam0/utils/cmsis/samr21/include; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_oled1_tickless_xpro_example_flash.bin
  ILINK.IlinkOutputFile: freertos_oled1_tickless_xpro_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/demo/oled1_tickless_xpro_example
    ../../: demotasks.c tickless.c main.c oled1.h demotasks.h documentation.h cdc.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samr21_xplained_pro
    ../: conf_demo.h conf_board.h conf_ssd1306.h conf_spi.h FreeRTOSConfig.h conf_clocks.h conf_sysfont.h
  group thirdparty/freertos/demo/oled1_tickless_xpro_example/samr21_xplained_pro/iar
    ./: asf.h
  group thirdparty/freertos/freertos-8.0.1/Source
    ../../../../freertos-8.0.1/Source/: tasks.c timers.c croutine.c queue.c event_groups.c list.c
  group thirdparty/freertos/freertos-8.0.1/Source/portable/MemMang
    ../../../../freertos-8.0.1/Source/portable/MemMang/: heap_1.c
  group thirdparty/freertos/freertos-8.0.1/Source/portable/IAR/ARM_CM0
    ../../../../freertos-8.0.1/Source/portable/IAR/ARM_CM0/: port_cm0_iar.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-8.0.1/Source/include
    ../../../../freertos-8.0.1/Source/include/: event_groups.h projdefs.h croutine.h FreeRTOS.h portable.h semphr.h task.h mpu_wrappers.h list.h timers.h StackMacros.h queue.h
  group common2/services/gfx_mono
    ../../../../../../common2/services/gfx_mono/: gfx_mono_text.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_ug_2832hsweg04.c sysfont.h gfx_mono.h gfx_mono_framebuffer.h gfx_mono_ug_2832hsweg04.h gfx_mono_text.h gfx_mono_generic.h
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common2/components/display/ssd1306
    ../../../../../../common2/components/display/ssd1306/: ssd1306.c ssd1306.h
  group sam0/drivers/tc
    ../../../../../../sam0/drivers/tc/: tc_interrupt.c tc_interrupt.h tc.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../sam0/boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../sam0/utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../sam0/utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../sam0/utils/cmsis/samr21/include/: samr21g18a.h samr21e17a.h samr21e16a.h samr21e18a.h samr21g17a.h samr21e19a.h samr21g16a.h samr21.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../sam0/utils/cmsis/samr21/include/component/: dmac.h sercom.h nvmctrl.h pac.h dsu.h ac.h hmatrixb.h rfctrl.h adc.h port.h tc.h wdt.h sysctrl.h evsys.h mtb.h eic.h gclk.h usb.h rtc.h pm.h tcc.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../sam0/utils/cmsis/samr21/include/instance/: mtb.h usb.h evsys.h gclk.h sercom1.h eic.h tc5.h sercom3.h sercom4.h sercom0.h tc4.h sercom5.h sercom2.h sbmatrix.h rtc.h tcc0.h pm.h pac0.h ac.h sysctrl.h adc.h wdt.h nvmctrl.h dsu.h dmac.h pac2.h tcc1.h tc3.h pac1.h port.h tcc2.h rfctrl.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../sam0/utils/cmsis/samr21/include/pio/: samr21e18a.h samr21e16a.h samr21e19a.h samr21g17a.h samr21g16a.h samr21e17a.h samr21g18a.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrecursion.h mrepeat.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
