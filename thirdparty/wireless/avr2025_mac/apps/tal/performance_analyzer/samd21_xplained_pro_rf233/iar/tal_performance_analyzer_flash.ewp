# IAR project tal_performance_analyzer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CUSTOM_DEFAULT_TX_PWR; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; EXT_RF_FRONT_END_CTRL; DISABLE_TSTAMP_IRQ=1; ANTENNA_DIVERSITY=0; ENABLE_TFA; _DEBUG_=0; TC_ASYNC=true; TRX_REG_RAW_VALUE; ARM_MATH_CM0PLUS=true; SPI_CALLBACK_MODE=false; ENABLE_DEEP_SLEEP; PAL_USE_SPI_TRX=1; FFD; BOARD=SAMD21_XPLAINED_PRO; EXTINT_CALLBACK_MODE=true; USART_CALLBACK_MODE=true; SYSTICK_MODE; TAL_TYPE=AT86RF233; CUSTOM_PWR_TABLE; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../source/mac/inc; ../../../../../../../../sam0/drivers/port; ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../addons/sio2host/uart; ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../sam0/utils/preprocessor; ../../../../../source/pal/common_sw_timer; ../../../../../../../../common2/services/delay; ../../../../../source/resources/queue/inc; ../../../../../../../../sam0/utils; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/boards; ../..; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../services/common_hw_timer/sam0; ../../../../../../../../common/services/serial; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/drivers/system/reset; ../../../../../source/tfa/inc; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../sam0/drivers/tc; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../services/common_hw_timer; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common2/services/delay/sam0; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h; ../../../../../../../../common/boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../inc; ../../../../../../../../sam0/drivers/extint; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/boards/samd21_xplained_pro; ..; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0
    ../../../../../../services/common_hw_timer/sam0/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam0/lib
    ../../../../../../services/common_hw_timer/sam0/lib/: sam0_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c init_state.c user_interface.c wait_for_event.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c peer_search_initiator.c performance_main.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/samd21_xplained_pro_rf233
    ../: conf_trx_access.h conf_sio2host.h conf_board.h conf_perf_analyzer.h conf_sleepmgr.h conf_extint.h conf_spi.h conf_clocks.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/samd21_xplained_pro_rf233/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: app_range_mode.h performance_main.h perf_api.h perf_msg_const.h app_peer_search.h user_interface.h app_frame_format.h perf_api_serial_handler.h app_config.h app_per_mode.h app_init.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_slotted_csma.c tal_pwr_mgmt.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../source/tal/at86rf233/inc/: tal_pib.h tal_internal.h tal_rx.h tal_slotted_csma.h tal_config.h tal_irq_handler.h tal_constants.h at86rf233.h tal_tx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_msg_type_data_ind.h mac_api.h mac_config.h mac_msg_const.h mac.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: ieee_154g.h avr2025_mac.h mac_build_config.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/tc
    ../../../../../../../../sam0/drivers/tc/: tc_interrupt.c tc.h tc_interrupt.h
  group sam0/drivers/tc/tc_sam_d_r_h
    ../../../../../../../../sam0/drivers/tc/tc_sam_d_r_h/: tc.c
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21e16l.h samd21j15a.h samd21g16l.h samd21e16bu.h samd21g16a.h samd21j17a.h samd21j16a.h samd21j16b.h samd21e17a.h samd21g15a.h samd21g17au.h samd21g16b.h samd21e18a.h samd21.h samd21e16b.h samd21g15l.h samd21e15bu.h samd21g15b.h samd21j15b.h samd21e15b.h samd21g18a.h samd21g18au.h samd21e16a.h samd21e15a.h samd21j18a.h samd21g17a.h samd21e15l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j16b.h samd21g18au.h samd21e16b.h samd21g17au.h samd21g15a.h samd21e15a.h samd21e18a.h samd21g17a.h samd21j15b.h samd21j15a.h samd21j16a.h samd21j18a.h samd21g16a.h samd21g16b.h samd21j17a.h samd21g18a.h samd21g15l.h samd21e16bu.h samd21e16l.h samd21e15bu.h samd21g15b.h samd21e15l.h samd21g16l.h samd21e17a.h samd21e15b.h samd21e16a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../sam0/utils/cmsis/samd21/include/component/: i2s.h ac.h evsys.h rtc.h pm.h mtb.h dsu.h hmatrixb.h eic.h pac.h tcc_lighting.h gclk.h wdt.h tcc.h tc.h sercom.h dmac.h sysctrl.h usb.h nvmctrl.h port.h dac.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: tcc2.h tc3.h pac0.h sbmatrix.h sercom2.h eic.h sercom0.h nvmctrl.h pac2.h usb.h sercom3.h pm.h tcc1.h sercom4.h pac1.h ac.h sercom5.h wdt.h dsu.h dmac.h i2s.h gclk.h tc7.h port.h ac1.h evsys.h sysctrl.h dac.h mtb.h rtc.h tcc0.h tc6.h tc5.h sercom1.h tc4.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h mrecursion.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
