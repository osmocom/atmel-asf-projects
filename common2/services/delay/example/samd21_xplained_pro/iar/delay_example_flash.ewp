# IAR project delay_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; __SAMD21J18A__; ARM_MATH_CM0PLUS=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../sam0/utils/preprocessor; ../../..; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/port; ../../../../../../sam0/boards; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../sam0/drivers/system/interrupt; ..; ../../../sam0; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_flash.bin
  ILINK.IlinkOutputFile: delay_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/services/delay
    ../../../: delay.h
  group common2/services/delay/sam0
    ../../../sam0/: systick_counter.c systick_counter.h
  group common2/services/delay/example
    ../../: delay_example.c
  group common2/services/delay/example/samd21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group common2/services/delay/example/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../sam0/utils/cmsis/samd21/include/: samd21g15l.h samd21e16a.h samd21e15a.h samd21j16a.h samd21.h samd21e15bu.h samd21g17a.h samd21j15a.h samd21e16l.h samd21j16b.h samd21g15a.h samd21e15b.h samd21g18au.h samd21e18a.h samd21e15l.h samd21g15b.h samd21g17au.h samd21e16bu.h samd21g16l.h samd21g18a.h samd21g16a.h samd21e17a.h samd21g16b.h samd21j18a.h samd21j17a.h samd21e16b.h samd21j15b.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j18a.h samd21e16bu.h samd21e16a.h samd21g16a.h samd21e18a.h samd21e15a.h samd21e15l.h samd21j17a.h samd21g15b.h samd21g16l.h samd21e16b.h samd21g17au.h samd21e17a.h samd21g17a.h samd21j15a.h samd21g18au.h samd21j16a.h samd21g15l.h samd21g18a.h samd21e15bu.h samd21e15b.h samd21g16b.h samd21g15a.h samd21j15b.h samd21e16l.h samd21j16b.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../sam0/utils/cmsis/samd21/include/component/: rtc.h eic.h nvmctrl.h usb.h hmatrixb.h dac.h sercom.h wdt.h dsu.h ac.h i2s.h adc.h port.h tcc.h mtb.h evsys.h pm.h tc.h tcc_lighting.h dmac.h gclk.h pac.h sysctrl.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../sam0/utils/cmsis/samd21/include/instance/: sercom3.h nvmctrl.h wdt.h tc5.h sercom1.h tc3.h port.h pac2.h usb.h sysctrl.h sercom2.h tcc2.h tc7.h ac1.h tc4.h tcc0.h pac0.h dsu.h i2s.h evsys.h dmac.h sbmatrix.h tcc1.h sercom5.h mtb.h eic.h rtc.h tc6.h sercom4.h sercom0.h pac1.h dac.h adc.h pm.h ac.h gclk.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
