# IAR project example_spinctrl_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SYSTICK_MODE; GFX_MONO_UG_2832HSWEG04=1; BOARD=SAMD21_XPLAINED_PRO; ARM_MATH_CM0PLUS=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../sam0/drivers/port; ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../..; ../../../../../../sam0/utils/preprocessor; ../../../../delay; ../../../../../../sam0/utils; ../../../../../../sam0/drivers/sercom/spi; ../../../../../../sam0/drivers/sercom; ../../../../../../sam0/drivers/system/power; ../../../../../../sam0/boards; ../../../../../components/display/ssd1306; ../../../../../../sam0/drivers/system/reset; ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../common/utils; ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../sam0/drivers/system/interrupt; ../../../../delay/sam0; ../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ..; ../..; ../../../../../../common/boards; ../../../../../../sam0/drivers/system/pinmux; ../../../../../../sam0/drivers/system; ../../../../../../sam0/utils/header_files; ../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_spinctrl_flash.bin
  ILINK.IlinkOutputFile: example_spinctrl_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../../../components/display/ssd1306/: ssd1306.c ssd1306.h
  group common2/services/gfx_mono
    ../../../: gfx_mono_ug_2832hsweg04.c gfx_mono_text.c gfx_mono_spinctrl.c sysfont.c gfx_mono_generic.c gfx_mono_framebuffer.c gfx_mono_text.h sysfont.h gfx_mono_generic.h gfx_mono_framebuffer.h gfx_mono.h gfx_mono_ug_2832hsweg04.h gfx_mono_spinctrl.h
  group common2/services/gfx_mono/example_spinctrl
    ../../: example_spinctrl.c
  group common2/services/gfx_mono/example_spinctrl/samd21_xplained_pro
    ../: conf_spinctrl.h conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h conf_sysfont.h
  group common2/services/gfx_mono/example_spinctrl/samd21_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../delay/: delay.h
  group common2/services/delay/sam0
    ../../../../delay/sam0/: systick_counter.c systick_counter.h
  group sam0/drivers/system
    ../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/sercom
    ../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/port
    ../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../sam0/utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../sam0/utils/cmsis/samd21/include/: samd21g15l.h samd21e16a.h samd21e15a.h samd21j16a.h samd21.h samd21e15bu.h samd21g17a.h samd21j15a.h samd21e16l.h samd21g15a.h samd21e15b.h samd21g18au.h samd21e18a.h samd21e15l.h samd21g15b.h samd21g17au.h samd21e16bu.h samd21g16l.h samd21g18a.h samd21g16a.h samd21j16b.h samd21e17a.h samd21g16b.h samd21j18a.h samd21j17a.h samd21e16b.h samd21j15b.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j18a.h samd21e16bu.h samd21g16a.h samd21e16a.h samd21e18a.h samd21e15a.h samd21e15l.h samd21j17a.h samd21g15b.h samd21g16l.h samd21e16b.h samd21g17au.h samd21g17a.h samd21j15a.h samd21g18au.h samd21j16a.h samd21g15l.h samd21g18a.h samd21e15bu.h samd21e15b.h samd21g15a.h samd21g16b.h samd21j15b.h samd21e16l.h samd21j16b.h samd21e17a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../sam0/utils/cmsis/samd21/include/component/: rtc.h eic.h nvmctrl.h usb.h i2s.h hmatrixb.h dac.h sercom.h wdt.h dsu.h ac.h sysctrl.h adc.h port.h tcc.h mtb.h evsys.h pm.h tc.h tcc_lighting.h dmac.h gclk.h pac.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../sam0/utils/cmsis/samd21/include/instance/: sercom3.h nvmctrl.h wdt.h tc5.h sercom1.h tc3.h port.h pac2.h usb.h sysctrl.h sercom2.h tcc2.h tc7.h ac1.h tc4.h tcc0.h pac0.h dsu.h i2s.h evsys.h sbmatrix.h tcc1.h sercom5.h mtb.h eic.h rtc.h tc6.h sercom4.h sercom0.h pac1.h dac.h adc.h pm.h ac.h gclk.h dmac.h
  group sam0/utils/preprocessor
    ../../../../../../sam0/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
