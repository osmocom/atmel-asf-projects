# IAR project example_hids_cdc_msc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; USART_CALLBACK_MODE=true; ACCESS_USB_ENABLED; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; VIRTUAL_MEMORY_ENABLE; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../cdc; ../../../../../cdc/device; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../msc; ../..; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../hid/device/mouse; ../../../../../msc/device; ../../../../../hid/device/kbd; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../../sam0/boards; ../../../../../hid/device; ../../../../../../../../boards; ..; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../hid; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_hids_cdc_msc_flash.bin
  ILINK.IlinkOutputFile: example_hids_cdc_msc_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x0B00
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21g18au.h samd21e16bu.h samd21g16a.h samd21g15l.h samd21.h samd21j16a.h samd21j15b.h samd21g18a.h samd21g17a.h samd21g15b.h samd21e17a.h samd21e15b.h samd21e16a.h samd21j16b.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e16b.h samd21e15a.h samd21g15a.h samd21g17au.h samd21g16b.h samd21g16l.h samd21e16l.h samd21e15bu.h samd21e15l.h samd21j15a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g16l.h samd21e15l.h samd21e15a.h samd21e15b.h samd21e16l.h samd21g15a.h samd21j15a.h samd21e17a.h samd21j17a.h samd21e16b.h samd21g15l.h samd21g15b.h samd21g16a.h samd21j16a.h samd21g18a.h samd21g17au.h samd21e16bu.h samd21j16b.h samd21g16b.h samd21e18a.h samd21g17a.h samd21e16a.h samd21j18a.h samd21j15b.h samd21g18au.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h mtb.h i2s.h tcc.h pm.h tc.h wdt.h gclk.h sysctrl.h pac.h rtc.h usb.h dsu.h sercom.h ac.h eic.h tcc_lighting.h dac.h nvmctrl.h hmatrixb.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h sercom1.h sercom3.h pac0.h pac2.h tc7.h mtb.h tc5.h adc.h dsu.h eic.h tcc2.h port.h tc3.h tcc0.h dac.h sercom4.h i2s.h sbmatrix.h nvmctrl.h gclk.h ac1.h wdt.h sercom0.h pac1.h sercom2.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h usb.h pm.h rtc.h tcc1.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/composite/device
    ../../../: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/composite/device/example2
    ../../: uart_samd.c main.c memories_initialization_samd.c uart.h conf_usb.h main.h ui.h
  group common/services/usb/class/composite/device/example2/samd21j18a_samd21_xplained_pro
    ../: ui.c conf_virtual_mem.h conf_board.h conf_sleepmgr.h conf_example.h conf_extint.h conf_access.h conf_clocks.h
  group common/services/usb/class/composite/device/example2/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/class/hid/device/kbd
    ../../../../../hid/device/kbd/: udi_hid_kbd.c udi_hid_kbd.h
  group common/services/usb/class/cdc
    ../../../../../cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../cdc/device/: udi_cdc.c udi_cdc.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../../../msc/device/: udi_msc.c udi_msc.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udc.h udd.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
