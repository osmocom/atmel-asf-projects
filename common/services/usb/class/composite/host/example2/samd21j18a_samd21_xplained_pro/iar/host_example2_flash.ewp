# IAR project host_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; RTC_CALENDAR_ASYNC=false; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USB_HOST_LPM_SUPPORT; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/port; ../../../../../hid/host/mouse; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../../sam0/utils/preprocessor; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/boards; ../../../../../../../../../sam0/drivers/usb; ../..; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/rtc; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../uhc; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../..; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ..; ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../msc/host; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../hid; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_flash.bin
  ILINK.IlinkOutputFile: host_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/rtc
    ../../../../../../../../../sam0/drivers/rtc/: rtc_calendar.h rtc_tamper.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_calendar.c
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21g18au.h samd21e16bu.h samd21g16a.h samd21g15l.h samd21.h samd21j16a.h samd21j15b.h samd21g18a.h samd21g17a.h samd21g15b.h samd21e17a.h samd21e15b.h samd21e16a.h samd21j16b.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e16b.h samd21e15a.h samd21g15a.h samd21g17au.h samd21g16b.h samd21g16l.h samd21e16l.h samd21e15bu.h samd21e15l.h samd21j15a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g16l.h samd21e15l.h samd21e15a.h samd21e15b.h samd21e16l.h samd21g15a.h samd21e17a.h samd21j17a.h samd21e16b.h samd21g15l.h samd21g15b.h samd21g16a.h samd21j16a.h samd21g18a.h samd21g17au.h samd21e16bu.h samd21j16b.h samd21g16b.h samd21e18a.h samd21e16a.h samd21j18a.h samd21j15a.h samd21j15b.h samd21g17a.h samd21g18au.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h i2s.h tcc.h mtb.h pm.h tc.h wdt.h gclk.h pac.h rtc.h sysctrl.h usb.h dsu.h ac.h eic.h sercom.h tcc_lighting.h dac.h nvmctrl.h hmatrixb.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h sercom1.h sercom3.h pac0.h pac2.h tc7.h mtb.h tc5.h sercom4.h adc.h dsu.h eic.h tcc2.h port.h tc3.h tcc0.h dac.h i2s.h sbmatrix.h nvmctrl.h gclk.h ac1.h usb.h wdt.h sercom0.h pac1.h sercom2.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h pm.h rtc.h tcc1.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/composite/host/example2
    ../../: main.c conf_access.h conf_usb_host.h conf_fatfs.h main.h ui.h
  group common/services/usb/class/composite/host/example2/samd21j18a_samd21_xplained_pro
    ../: ui.c conf_board.h conf_sleepmgr.h conf_clocks.h conf_extint.h
  group common/services/usb/class/composite/host/example2/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ffconf.h ff.h diskio.h integer.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
