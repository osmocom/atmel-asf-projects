# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; USART_CALLBACK_MODE=true; ACCESS_USB_ENABLED; EXTINT_CALLBACK_MODE=true; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM0PLUS=true; USB_DEVICE_LPM_SUPPORT; VIRTUAL_MEMORY_ENABLE; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../../sam0/drivers/system/power; ../../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../../sam0/utils/preprocessor; ../../../..; ../../../../../../../../../sam0/utils; ../../../../../../../../../sam0/drivers/sercom; ../../../../../../../../../sam0/drivers/port; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../serial; ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../../sam0/drivers/system/interrupt; ../../..; ..; ../../../../../../udc; ../../../../../..; ../..; ../../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../../sam0/boards; ../../../../../../../../boards; ../../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../../sam0/drivers/usb; ../../../../../../../../../sam0/drivers/system; ../../../../../../../../../sam0/drivers/extint; ../../../../../../../../../sam0/utils/header_files; ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../storage/ctrl_access; ../../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/extint
    ../../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/sercom
    ../../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/usb
    ../../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../../sam0/drivers/usb/stack_interface/: usb_device_udd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/utils
    ../../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21g18au.h samd21g16a.h samd21g15l.h samd21.h samd21e16bu.h samd21j15b.h samd21g18a.h samd21g17a.h samd21j16a.h samd21g15b.h samd21e17a.h samd21e15b.h samd21e16a.h samd21j16b.h samd21e18a.h samd21j18a.h samd21j17a.h samd21e16b.h samd21e15a.h samd21g15a.h samd21g17au.h samd21g16b.h samd21g16l.h samd21e16l.h samd21e15bu.h samd21e15l.h samd21j15a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21g16l.h samd21e15l.h samd21e15b.h samd21e16l.h samd21g15a.h samd21j15a.h samd21e17a.h samd21j17a.h samd21e16b.h samd21g15l.h samd21g15b.h samd21g16a.h samd21j16a.h samd21g18a.h samd21e15a.h samd21g17au.h samd21e16bu.h samd21j16b.h samd21g16b.h samd21e18a.h samd21g17a.h samd21e16a.h samd21j18a.h samd21j15b.h samd21g18au.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/component/: port.h dmac.h evsys.h mtb.h i2s.h tcc.h pm.h tc.h wdt.h gclk.h pac.h rtc.h sysctrl.h usb.h dac.h dsu.h sercom.h ac.h eic.h tcc_lighting.h nvmctrl.h hmatrixb.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: ac.h sercom1.h sercom3.h pac0.h pac2.h tc7.h mtb.h tc5.h adc.h dsu.h eic.h tcc2.h port.h tc3.h tcc0.h dac.h i2s.h sbmatrix.h nvmctrl.h gclk.h ac1.h usb.h sercom4.h wdt.h sercom0.h pac1.h sercom2.h tc6.h evsys.h sysctrl.h dmac.h sercom5.h tc4.h pm.h rtc.h tcc1.h
  group sam0/utils/stdio
    ../../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../../../sam0/utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: usb_protocol_msc.h spc_protocol.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_samd.c unit_tests.h conf_usb.h
  group common/services/usb/class/msc/device/unit_tests/samd21j18a_samd21_xplained_pro
    ../: conf_virtual_mem.h conf_board.h conf_sleepmgr.h conf_test.h conf_access.h conf_clocks.h conf_extint.h
  group common/services/usb/class/msc/device/unit_tests/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udc.h udd.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
