# IAR project tests_targets_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; USB_HOST_LPM_SUPPORT; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../sam0/drivers/port; ../../../../../class/hid/host/mouse; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../common2/services/delay; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../serial; ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../sam0/drivers/system/interrupt; ../../../..; ../..; ../../../../..; ..; ../../../../../../../../sam0/drivers/usb/usb_sam_d_r; ../../../../../../../../common2/services/delay/sam0; ../../../../../../../../sam0/drivers/usb/stack_interface; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/usb; ../../../../../../../../sam0/drivers/system; ../../../../../../../../sam0/drivers/extint; ../../../../../class/hid; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_targets_flash.bin
  ILINK.IlinkOutputFile: tests_targets_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/usb
    ../../../../../../../../sam0/drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../../../../sam0/drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../../../../sam0/drivers/usb/usb_sam_d_r/: usb.c
  group sam0/drivers/extint
    ../../../../../../../../sam0/drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../../../../sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21e16l.h samd21j15a.h samd21g16l.h samd21e16bu.h samd21g16a.h samd21j17a.h samd21g16b.h samd21j16a.h samd21j16b.h samd21e17a.h samd21g15a.h samd21g17au.h samd21e18a.h samd21.h samd21g17a.h samd21e16b.h samd21g15l.h samd21g15b.h samd21j15b.h samd21e15b.h samd21g18a.h samd21e16a.h samd21g18au.h samd21e15a.h samd21j18a.h samd21e15bu.h samd21e15l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j16b.h samd21g18au.h samd21j15a.h samd21e16b.h samd21g17au.h samd21g15a.h samd21e15a.h samd21e18a.h samd21g17a.h samd21j15b.h samd21j16a.h samd21j18a.h samd21g16a.h samd21g16b.h samd21j17a.h samd21g18a.h samd21e16bu.h samd21e16l.h samd21e15bu.h samd21g15b.h samd21g15l.h samd21e15l.h samd21g16l.h samd21e17a.h samd21e15b.h samd21e16a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../sam0/utils/cmsis/samd21/include/component/: i2s.h ac.h evsys.h dsu.h rtc.h pm.h mtb.h hmatrixb.h eic.h pac.h tcc_lighting.h gclk.h wdt.h tcc.h tc.h sercom.h dmac.h sysctrl.h usb.h nvmctrl.h port.h dac.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: tcc1.h tcc2.h tc3.h pac0.h sbmatrix.h sercom2.h eic.h sercom0.h nvmctrl.h pac2.h usb.h pm.h sercom4.h pac1.h ac.h sercom5.h dsu.h mtb.h gclk.h wdt.h i2s.h tc7.h evsys.h port.h ac1.h sysctrl.h dac.h rtc.h tcc0.h adc.h tc6.h tc4.h dmac.h sercom3.h tc5.h sercom1.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/usb
    ../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/uhc
    ../../../../: uhc.c uhd.h uhi.h uhc.h
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c unit_tests.h conf_usb_host.h
  group common/services/usb/uhc/unit_tests/target/samd21j18a_samd21_xplained_pro
    ../: conf_board.h conf_sleepmgr.h conf_test.h conf_clocks.h conf_extint.h
  group common/services/usb/uhc/unit_tests/target/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group common/services/usb/class/hid
    ../../../../../class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/sleepmgr
    ../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/boards
    ../../../../../../../boards/: board.h
  group common2/services/delay
    ../../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
