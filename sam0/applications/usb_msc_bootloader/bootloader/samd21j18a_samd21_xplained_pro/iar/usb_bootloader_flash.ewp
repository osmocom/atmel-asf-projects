# IAR project usb_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYCLE_MODE; BOARD=SAMD21_XPLAINED_PRO; RTC_CALENDAR_ASYNC=false; EXTINT_CALLBACK_MODE=true; UHD_ENABLE; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; USB_HOST_LPM_SUPPORT; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../../drivers/system/interrupt; ../../../../../drivers/port; ../../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../common/boards; ../../../../../drivers/extint/extint_sam_d_r_h; ../../../../../utils/preprocessor; ../../../../../../common/services/usb/class/msc; ../../../../../drivers/dma; ../../../../../../common2/services/delay; ../../../../../utils; ../../../../../drivers/nvm; ../../../../../drivers/sercom; ../../../../../drivers/system/power; ../../../../../boards; ../../../../../drivers/sercom/usart; ../../../../../../common/services/serial; ../../../../../drivers/system/reset; ../../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../drivers/rtc/rtc_sam_d_r_h; ../../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../../utils/cmsis/samd21/include; ../../../../../../common/services/usb/uhc; ../../../../../drivers/usb/stack_interface; ../../../../../drivers/rtc; ../../../../../../common/services/usb; ../../../../../drivers/system/power/power_sam_d_r_h; ../../../../../drivers/usb/usb_sam_d_r; ../..; ../../../../../../common2/services/delay/sam0; ../../../../../../common/services/usb/class/msc/host; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ..; ../../../../../drivers/system/pinmux; ../../../../../drivers/usb; ../../../../../drivers/system; ../../../../../drivers/extint; ../../../../../utils/header_files; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../boards/samd21_xplained_pro; ../../../../../utils/stdio/stdio_serial; ../../../../../../common/services/storage/ctrl_access; ../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usb_bootloader_flash.bin
  ILINK.IlinkOutputFile: usb_bootloader_flash.out
  ILINK.IlinkIcfFile: ../linker_scripts/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c integer.h ff.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group common2/services/delay
    ../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
  group sam0/drivers/system
    ../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/usb
    ../../../../../drivers/usb/: usb.h
  group sam0/drivers/usb/stack_interface
    ../../../../../drivers/usb/stack_interface/: usb_host_uhd.c usb_dual.c usb_dual.h
  group sam0/drivers/usb/usb_sam_d_r
    ../../../../../drivers/usb/usb_sam_d_r/: usb.c
  group sam0/drivers/dma
    ../../../../../drivers/dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../../drivers/dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/port
    ../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/extint
    ../../../../../drivers/extint/: extint_callback.c extint.h extint_callback.h
  group sam0/drivers/extint/extint_sam_d_r_h
    ../../../../../drivers/extint/extint_sam_d_r_h/: extint.c
  group sam0/drivers/rtc
    ../../../../../drivers/rtc/: rtc_tamper.h rtc_calendar.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../drivers/rtc/rtc_sam_d_r_h/: rtc_calendar.c
  group sam0/drivers/sercom
    ../../../../../drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../drivers/sercom/usart/: usart.c usart_interrupt.c usart.h usart_interrupt.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/nvm
    ../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21g15b.h samd21g16b.h samd21g18au.h samd21e15a.h samd21e16l.h samd21g17a.h samd21g15a.h samd21e16a.h samd21g17au.h samd21g16a.h samd21e18a.h samd21g18a.h samd21j15a.h samd21j18a.h samd21e16b.h samd21j15b.h samd21e17a.h samd21e15bu.h samd21e16bu.h samd21j16b.h samd21j16a.h samd21e15b.h samd21.h samd21g15l.h samd21j17a.h samd21g16l.h samd21e15l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: samd21e18a.h samd21j15b.h samd21e15b.h samd21g17au.h samd21g15l.h samd21j17a.h samd21j15a.h samd21g16l.h samd21g16b.h samd21e16b.h samd21j16a.h samd21j18a.h samd21g18au.h samd21g15a.h samd21e16a.h samd21e16bu.h samd21g18a.h samd21e15bu.h samd21e15a.h samd21g15b.h samd21j16b.h samd21e17a.h samd21g16a.h samd21e15l.h samd21g17a.h samd21e16l.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: usb.h dsu.h eic.h ac1.h gclk.h sbmatrix.h tc4.h tc6.h port.h pm.h wdt.h ac.h tcc1.h tc3.h pac2.h sercom4.h sercom2.h evsys.h tc5.h tc7.h sercom1.h rtc.h tcc0.h dmac.h sercom5.h sercom3.h sysctrl.h sercom0.h i2s.h tcc2.h adc.h pac1.h nvmctrl.h mtb.h pac0.h dac.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: tcc.h sysctrl.h tcc_lighting.h gclk.h dmac.h wdt.h rtc.h evsys.h usb.h tc.h hmatrixb.h mtb.h sercom.h dac.h dsu.h port.h i2s.h pac.h adc.h pm.h nvmctrl.h ac.h eic.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/applications/usb_msc_bootloader/bootloader
    ../../: main.c main.h
  group sam0/applications/usb_msc_bootloader/bootloader/samd21j18a_samd21_xplained_pro
    ../: conf_sleepmgr.h conf_extint.h conf_board.h conf_bootloader.h conf_dma.h conf_uart_serial.h conf_access.h conf_usb_host.h conf_fatfs.h conf_clocks.h
  group sam0/applications/usb_msc_bootloader/bootloader/samd21j18a_samd21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/usb
    ../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/uhc
    ../../../../../../common/services/usb/uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/services/usb/class/msc
    ../../../../../../common/services/usb/class/msc/: usb_protocol_msc.h sbc_protocol.h spc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../../common/services/usb/class/msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/samd
    ../../../../../../common/services/sleepmgr/samd/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
