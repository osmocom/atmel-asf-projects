# IAR project sleepwalking_adc_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=true; SYSTICK_MODE; BOARD=SAMD21_XPLAINED_PRO; EVENTS_INTERRUPT_HOOKS_MODE=true; RTC_COUNT_ASYNC=false; ARM_MATH_CM0PLUS=true; __SAMD21J18A__
  ICCARM.CCIncludePath2: ../../../../utils/cmsis/samd21/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/power; ../../../../drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../drivers/adc; ../../../../utils/preprocessor; ../../../../../common2/services/delay; ../../../../utils; ../../../../drivers/port; ../../../../boards; ..; ../../../../drivers/system/reset; ../../../../drivers/system/reset/reset_sam_d_r_h; ../../../../../common/utils; ../../../../drivers/events/events_sam_d_r_h; ../../../../drivers/rtc/rtc_sam_d_r_h; ../../../../drivers/system/interrupt/system_interrupt_samd21; ../../../../utils/cmsis/samd21/include; ../../../../drivers/rtc; ../../../../drivers/adc/adc_sam_d_r_h; ../../../../../common2/services/delay/sam0; ../../../../drivers/system/power/power_sam_d_r_h; ../../../../../common/boards; ../..; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../drivers/events; ../../../../utils/header_files; ../../../../boards/samd21_xplained_pro; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sleepwalking_adc_flash.bin
  ILINK.IlinkOutputFile: sleepwalking_adc_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/adc
    ../../../../drivers/adc/: adc_callback.h adc.h
  group sam0/drivers/adc/adc_sam_d_r_h
    ../../../../drivers/adc/adc_sam_d_r_h/: adc_callback.c adc.c adc_feature.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/rtc
    ../../../../drivers/rtc/: rtc_tamper.h rtc_count.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../drivers/rtc/rtc_sam_d_r_h/: rtc_count.c
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/events
    ../../../../drivers/events/: events_hooks.c events.h events_hooks.h events_common.h
  group sam0/drivers/events/events_sam_d_r_h
    ../../../../drivers/events/events_sam_d_r_h/: events.c
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../utils/cmsis/samd21/include/: samd21g18au.h samd21e16l.h samd21j16b.h samd21j18a.h samd21g16b.h samd21g18a.h samd21e15l.h samd21j15a.h samd21g17a.h samd21g17au.h samd21.h samd21g16a.h samd21e15bu.h samd21g15l.h samd21e16b.h samd21e15a.h samd21g16l.h samd21j15b.h samd21e16bu.h samd21e18a.h samd21g15a.h samd21e15b.h samd21e16a.h samd21e17a.h samd21g15b.h samd21j17a.h samd21j16a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../utils/cmsis/samd21/include/pio/: samd21g15a.h samd21g15b.h samd21g15l.h samd21j15b.h samd21e15bu.h samd21j16a.h samd21j15a.h samd21g16l.h samd21e15l.h samd21g16a.h samd21g18a.h samd21j18a.h samd21g17au.h samd21e16bu.h samd21e16l.h samd21e18a.h samd21g16b.h samd21e16a.h samd21e15b.h samd21j17a.h samd21g17a.h samd21j16b.h samd21e17a.h samd21e16b.h samd21g18au.h samd21e15a.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../utils/cmsis/samd21/include/instance/: tcc2.h tcc0.h dac.h dsu.h tcc1.h usb.h tc5.h eic.h wdt.h rtc.h dmac.h gclk.h tc4.h sercom5.h pac2.h port.h sercom1.h tc6.h pac1.h pac0.h evsys.h sercom2.h sercom4.h pm.h ac1.h ac.h sercom3.h sercom0.h nvmctrl.h sysctrl.h adc.h tc3.h sbmatrix.h i2s.h mtb.h tc7.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../utils/cmsis/samd21/include/component/: mtb.h i2s.h usb.h tc.h dsu.h evsys.h tcc.h adc.h rtc.h port.h pac.h hmatrixb.h pm.h eic.h gclk.h sercom.h nvmctrl.h tcc_lighting.h wdt.h dac.h sysctrl.h ac.h dmac.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/applications/sleepwalking_adc
    ../../: vcc_monitor.c
  group sam0/applications/sleepwalking_adc/samd21_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/applications/sleepwalking_adc/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samd21_xplained_pro
    ../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../common2/services/delay/sam0/: systick_counter.c systick_counter.h
