# IAR project bod_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMD21J18A__; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../../utils/cmsis/samd21/include; ../../../../port; ../../../../../boards; ../../..; ../../../../../../common/boards; ../../../../system/pinmux; ..; ../../../../../utils/preprocessor; ../../../../../utils/header_files; ../../../../../../common/utils; ../../../../../utils; ../..; ../../../bod_sam_d_r_h; ../../../../../boards/samd21_xplained_pro; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bod_quick_start_flash.bin
  ILINK.IlinkOutputFile: bod_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21g15b.h samd21g18au.h samd21e15a.h samd21e16l.h samd21g17a.h samd21g15a.h samd21e16a.h samd21j16b.h samd21g17au.h samd21g16a.h samd21e18a.h samd21g18a.h samd21j15a.h samd21j18a.h samd21e16b.h samd21e15l.h samd21e16bu.h samd21j15b.h samd21e17a.h samd21g16b.h samd21j16a.h samd21e15b.h samd21.h samd21g15l.h samd21e15bu.h samd21j17a.h samd21g16l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: samd21e18a.h samd21j15b.h samd21e15b.h samd21g15l.h samd21j17a.h samd21j15a.h samd21g17au.h samd21g16l.h samd21g16b.h samd21j16a.h samd21j18a.h samd21g18au.h samd21g15a.h samd21e16a.h samd21e16bu.h samd21g18a.h samd21e15bu.h samd21e15a.h samd21g15b.h samd21e16b.h samd21j16b.h samd21e17a.h samd21g16a.h samd21e15l.h samd21g17a.h samd21e16l.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: usb.h dsu.h eic.h ac1.h gclk.h sbmatrix.h pac0.h tc4.h tc6.h port.h pm.h wdt.h ac.h tcc1.h tc3.h pac2.h sercom4.h sercom2.h evsys.h tc5.h tc7.h sercom1.h rtc.h tcc0.h dmac.h sercom5.h sercom3.h sysctrl.h sercom0.h i2s.h tcc2.h adc.h pac1.h nvmctrl.h mtb.h dac.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: tcc.h sysctrl.h tcc_lighting.h gclk.h dsu.h evsys.h dmac.h wdt.h rtc.h usb.h tc.h hmatrixb.h adc.h mtb.h sercom.h dac.h port.h i2s.h pac.h pm.h nvmctrl.h ac.h eic.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/drivers/bod
    ../../../: bod.h
  group sam0/drivers/bod/quick_start
    ../../: qs_bod_basic_use.c
  group sam0/drivers/bod/quick_start/samd21_xplained_pro
    ../: conf_board.h
  group sam0/drivers/bod/quick_start/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/bod/bod_sam_d_r_h
    ../../../bod_sam_d_r_h/: bod.c bod_feature.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
