# IAR project spi_master_vec_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samd21/source; ../../../../../system/interrupt; ../../../../../system/power; ../../../../../system/clock/clock_samd21_r21_da_ha1; ../../../../../../utils/preprocessor; ../../../../spi; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ../../../../../system/reset; ../../../../../system/reset/reset_sam_d_r_h; ../../../../../../../common/utils; ../../../../../../boards/samd21_xplained_pro; ../../../../../../utils/cmsis/samd21/include; ../..; ../../..; ../../../../../system/power/power_sam_d_r_h; ../../../../../../../common/boards; ../config; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../system/interrupt/system_interrupt_samd21; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: spi_master_vec_quick_start_flash.bin
  ILINK.IlinkOutputFile: spi_master_vec_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/spi
    ../../../../spi/: spi_interrupt.c spi.c spi_interrupt.h spi.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi_master_vec
    ../../../: spi_master_vec.c spi_master_vec.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic
    ../../: qs_spi_master_vec_basic.c qs_spi_master_vec_basic.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samd21_xplained_pro/config
    ../config/: conf_spi_master_vec.h conf_spi.h conf_clocks.h conf_board.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../utils/cmsis/samd21/include/: samd21e17a.h samd21g16l.h samd21e15a.h samd21e15l.h samd21g15l.h samd21e15b.h samd21g15a.h samd21.h samd21g16b.h samd21j15a.h samd21g17a.h samd21e16b.h samd21j17a.h samd21g16a.h samd21g15b.h samd21j16a.h samd21g18a.h samd21j15b.h samd21e18a.h samd21e16bu.h samd21g17au.h samd21j16b.h samd21e16a.h samd21j18a.h samd21e16l.h samd21g18au.h samd21e15bu.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../utils/cmsis/samd21/include/instance/: tc6.h pac0.h tc5.h wdt.h gclk.h nvmctrl.h sercom5.h sbmatrix.h sercom1.h ac.h dsu.h sercom3.h pac1.h pm.h tcc1.h i2s.h tc4.h usb.h port.h ac1.h sercom4.h tcc0.h evsys.h sercom2.h eic.h tcc2.h sercom0.h pac2.h dmac.h dac.h tc7.h rtc.h tc3.h adc.h sysctrl.h mtb.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../utils/cmsis/samd21/include/pio/: samd21e16b.h samd21g16l.h samd21e15a.h samd21e15bu.h samd21j15a.h samd21g15b.h samd21e15l.h samd21j16a.h samd21g15a.h samd21j16b.h samd21j15b.h samd21e16l.h samd21g16a.h samd21g15l.h samd21g16b.h samd21e15b.h samd21j17a.h samd21e18a.h samd21g18au.h samd21g17a.h samd21j18a.h samd21e16a.h samd21e17a.h samd21g18a.h samd21g17au.h samd21e16bu.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../utils/cmsis/samd21/include/component/: ac.h nvmctrl.h sercom.h usb.h pac.h tcc.h port.h dac.h sysctrl.h mtb.h evsys.h gclk.h pm.h hmatrixb.h eic.h rtc.h tc.h tcc_lighting.h dmac.h wdt.h i2s.h adc.h dsu.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
